<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.6'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>48000</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
<param><key>freq</key><value>-1000</value></param>
<param><key>amp</key><value>0.95</value></param>
<param><key>offset</key><value>0</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>RxPre</value></param>
<param><key>type</key><value>int</value></param>
<param><key>num_opts</key><value>2</value></param>
<param><key>value</key><value>0</value></param>
<param><key>option0</key><value>0</value></param>
<param><key>label0</key><value>Off</value></param>
<param><key>option1</key><value>1</value></param>
<param><key>label1</key><value>On</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>Sideband</value></param>
<param><key>type</key><value>int</value></param>
<param><key>num_opts</key><value>2</value></param>
<param><key>value</key><value>-1</value></param>
<param><key>option0</key><value>-1</value></param>
<param><key>label0</key><value>Lower</value></param>
<param><key>option1</key><value>1</value></param>
<param><key>label1</key><value>Upper</value></param>
<param><key>widget</key><value>radio_buttons</value></param>
<param><key>gui_hint</key><value>1,2,1,1</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>PTT</value></param>
<param><key>type</key><value>int</value></param>
<param><key>num_opts</key><value>3</value></param>
<param><key>value</key><value>0</value></param>
<param><key>option0</key><value>0</value></param>
<param><key>label0</key><value>Off</value></param>
<param><key>option1</key><value>1</value></param>
<param><key>label1</key><value>Vox</value></param>
<param><key>option2</key><value>2</value></param>
<param><key>label2</key><value>On</value></param>
<param><key>widget</key><value>radio_buttons</value></param>
<param><key>gui_hint</key><value>1,1,1,1</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>TxF</value></param>
<param><key>value</key><value>7000000</value></param>
<param><key>start</key><value>1000000</value></param>
<param><key>stop</key><value>54000000</value></param>
<param><key>step</key><value>500000</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>min_len</key><value>500</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>squelch</value></param>
<param><key>value</key><value>-150</value></param>
<param><key>start</key><value>-200</value></param>
<param><key>stop</key><value>0</value></param>
<param><key>step</key><value>5</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>min_len</key><value>500</value></param>
<param><key>gui_hint</key><value>1,4,1,1</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>drive</value></param>
<param><key>type</key><value>raw</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>1,3,1,1</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>FreqFine</value></param>
<param><key>value</key><value>00000</value></param>
<param><key>start</key><value>000000</value></param>
<param><key>stop</key><value>500000</value></param>
<param><key>step</key><value>500</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>min_len</key><value>500</value></param>
</block>
<block>
<key>blocks_wavfile_sink</key>
<param><key>id</key><value>blocks_wavfile_sink_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>file</key><value>/home/tom/Desktop/SW_audio</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>bits_per_sample</key><value>16</value></param>
</block>
<block>
<key>hpsdr_hermesNB</key>
<param><key>id</key><value>hpsdr_hermesNB_0</value></param>
<param><key>Rx0F</key><value>RxF0+Sideband*1500+FreqFine</value></param>
<param><key>Rx1F</key><value>200000</value></param>
<param><key>TxF</key><value>TxF+FreqFine</value></param>
<param><key>RxSmp</key><value>384000</value></param>
<param><key>RxPre</key><value>RxPre</value></param>
<param><key>PTTRx</key><value>1</value></param>
<param><key>PTTTx</key><value>1</value></param>
<param><key>PTTmode</key><value>PTT</value></param>
<param><key>TxDrive</key><value>drive</value></param>
<param><key>Intfc</key><value>"eth0"</value></param>
<param><key>CkS</key><value>"0xF0"</value></param>
<param><key>AlexTA</key><value>0</value></param>
<param><key>AlexRA</key><value>0xa0</value></param>
<param><key>AlexHPF</key><value>0x00</value></param>
<param><key>AlexLPF</key><value>0x00</value></param>
<param><key>Verbose</key><value>0</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>samp_rate</key><value>48000</value></param>
<param><key>ok_to_block</key><value>False</value></param>
</block>
<block>
<key>blocks_complex_to_float</key>
<param><key>id</key><value>blocks_complex_to_float_0</value></param>
<param><key>_enabled</key><value>False</value></param>
</block>
<block>
<key>analog_agc3_xx</key>
<param><key>id</key><value>analog_agc3_xx_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>attack_rate</key><value>1</value></param>
<param><key>decay_rate</key><value>1e-5</value></param>
<param><key>reference</key><value>0.5</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>max_gain</key><value>65536</value></param>
<param><key>iir_update_decim</key><value>1</value></param>
</block>
<block>
<key>analog_pwr_squelch_xx</key>
<param><key>id</key><value>analog_pwr_squelch_xx_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>threshold</key><value>squelch</value></param>
<param><key>alpha</key><value>.00001</value></param>
<param><key>ramp</key><value>1</value></param>
<param><key>gate</key><value>False</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
<param><key>freq</key><value>Sideband*1500</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>offset</key><value>0</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>gain</key><value>250</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>cutoff_freq</key><value>1500</value></param>
<param><key>width</key><value>200</value></param>
<param><key>win</key><value>firdes.WIN_BLACKMAN</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>name</key><value>QT GUI Plot</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>fc</key><value>RxF0+Sideband*1500+FreqFine</value></param>
<param><key>bw</key><value>384000</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>ymin</key><value>-200</value></param>
<param><key>ymax</key><value>-50</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>label1</key><value>PreFilter</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>RxF0</value></param>
<param><key>value</key><value>14175000</value></param>
<param><key>start</key><value>500000</value></param>
<param><key>stop</key><value>54000000</value></param>
<param><key>step</key><value>500000</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>min_len</key><value>500</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>/home/jra/gr-projects/n8ur_2May2015_1618EDT_384k_14175kHz_raw_capture.bin</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<connection><source_block_id>hpsdr_hermesNB_0</source_block_id><sink_block_id>low_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0</source_block_id><sink_block_id>audio_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>hpsdr_hermesNB_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_agc3_xx_0</source_block_id><sink_block_id>blocks_complex_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_1</source_block_id><sink_block_id>hpsdr_hermesNB_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0</source_block_id><sink_block_id>blocks_wavfile_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>analog_pwr_squelch_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_pwr_squelch_xx_0</source_block_id><sink_block_id>analog_agc3_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>hpsdr_hermesNB_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
