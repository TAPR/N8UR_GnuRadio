<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>nbfm_block_9ch</value></param>
<param><key>author</key><value>John Ackermann N8UR jra@febo.com</value></param>
<param><key>category</key><value>N8UR</value></param>
<param><key>description</key><value>9 nbfm_blocks with an adder on the output</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>9 Channel NBFM RX block</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>audio_rate</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_inputs</key><value>9</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>fm_dev</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>5000</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>mute0</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>mute1</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>mute2</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>mute3</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>mute4</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>mute5</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>mute6</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>mute7</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>mute8</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>nbfm_block</key>
<param><key>id</key><value>nbfm_block_0_1_1_0</value></param>
<param><key>audio_rate</key><value>audio_rate</value></param>
<param><key>fm_dev</key><value>fm_dev</value></param>
<param><key>mute</key><value>mute0</value></param>
<param><key>quad_rate</key><value>quad_rate</value></param>
<param><key>sq_alpha</key><value>sq_alpha</value></param>
<param><key>sq_ramp</key><value>sq_ramp</value></param>
<param><key>squelch</key><value>squelch</value></param>
</block>
<block>
<key>nbfm_block</key>
<param><key>id</key><value>nbfm_block_0_1_1_0_0</value></param>
<param><key>audio_rate</key><value>audio_rate</value></param>
<param><key>fm_dev</key><value>fm_dev</value></param>
<param><key>mute</key><value>mute1</value></param>
<param><key>quad_rate</key><value>quad_rate</value></param>
<param><key>sq_alpha</key><value>sq_alpha</value></param>
<param><key>sq_ramp</key><value>sq_ramp</value></param>
<param><key>squelch</key><value>squelch</value></param>
</block>
<block>
<key>nbfm_block</key>
<param><key>id</key><value>nbfm_block_0_1_1_0_0_0</value></param>
<param><key>audio_rate</key><value>audio_rate</value></param>
<param><key>fm_dev</key><value>fm_dev</value></param>
<param><key>mute</key><value>mute2</value></param>
<param><key>quad_rate</key><value>quad_rate</value></param>
<param><key>sq_alpha</key><value>sq_alpha</value></param>
<param><key>sq_ramp</key><value>sq_ramp</value></param>
<param><key>squelch</key><value>squelch</value></param>
</block>
<block>
<key>nbfm_block</key>
<param><key>id</key><value>nbfm_block_0_1_1_0_0_0_0</value></param>
<param><key>audio_rate</key><value>audio_rate</value></param>
<param><key>fm_dev</key><value>fm_dev</value></param>
<param><key>mute</key><value>mute3</value></param>
<param><key>quad_rate</key><value>quad_rate</value></param>
<param><key>sq_alpha</key><value>sq_alpha</value></param>
<param><key>sq_ramp</key><value>sq_ramp</value></param>
<param><key>squelch</key><value>squelch</value></param>
</block>
<block>
<key>nbfm_block</key>
<param><key>id</key><value>nbfm_block_0_1_1_0_0_0_0_0</value></param>
<param><key>audio_rate</key><value>audio_rate</value></param>
<param><key>fm_dev</key><value>fm_dev</value></param>
<param><key>mute</key><value>mute4</value></param>
<param><key>quad_rate</key><value>quad_rate</value></param>
<param><key>sq_alpha</key><value>sq_alpha</value></param>
<param><key>sq_ramp</key><value>sq_ramp</value></param>
<param><key>squelch</key><value>squelch</value></param>
</block>
<block>
<key>nbfm_block</key>
<param><key>id</key><value>nbfm_block_0_1_1_0_0_0_0_0_0</value></param>
<param><key>audio_rate</key><value>audio_rate</value></param>
<param><key>fm_dev</key><value>fm_dev</value></param>
<param><key>mute</key><value>mute5</value></param>
<param><key>quad_rate</key><value>quad_rate</value></param>
<param><key>sq_alpha</key><value>sq_alpha</value></param>
<param><key>sq_ramp</key><value>sq_ramp</value></param>
<param><key>squelch</key><value>squelch</value></param>
</block>
<block>
<key>nbfm_block</key>
<param><key>id</key><value>nbfm_block_0_1_1_0_0_0_0_0_0_0</value></param>
<param><key>audio_rate</key><value>audio_rate</value></param>
<param><key>fm_dev</key><value>fm_dev</value></param>
<param><key>mute</key><value>mute7</value></param>
<param><key>quad_rate</key><value>quad_rate</value></param>
<param><key>sq_alpha</key><value>sq_alpha</value></param>
<param><key>sq_ramp</key><value>sq_ramp</value></param>
<param><key>squelch</key><value>squelch</value></param>
</block>
<block>
<key>nbfm_block</key>
<param><key>id</key><value>nbfm_block_0_1_1_0_0_0_0_0_0_0_0</value></param>
<param><key>audio_rate</key><value>audio_rate</value></param>
<param><key>fm_dev</key><value>fm_dev</value></param>
<param><key>mute</key><value>mute6</value></param>
<param><key>quad_rate</key><value>quad_rate</value></param>
<param><key>sq_alpha</key><value>sq_alpha</value></param>
<param><key>sq_ramp</key><value>sq_ramp</value></param>
<param><key>squelch</key><value>squelch</value></param>
</block>
<block>
<key>nbfm_block</key>
<param><key>id</key><value>nbfm_block_0_1_1_0_0_0_0_0_0_0_1</value></param>
<param><key>audio_rate</key><value>audio_rate</value></param>
<param><key>fm_dev</key><value>fm_dev</value></param>
<param><key>mute</key><value>mute8</value></param>
<param><key>quad_rate</key><value>quad_rate</value></param>
<param><key>sq_alpha</key><value>sq_alpha</value></param>
<param><key>sq_ramp</key><value>sq_ramp</value></param>
<param><key>squelch</key><value>squelch</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>label</key><value>mplex_audio</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>ch0_bb_in</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_1</value></param>
<param><key>label</key><value>ch1_bb_in</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_2</value></param>
<param><key>label</key><value>ch2_bb_in</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_3</value></param>
<param><key>label</key><value>ch3_bb_in</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_4</value></param>
<param><key>label</key><value>ch4_bb_in</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_5</value></param>
<param><key>label</key><value>ch5_bb_in</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_6</value></param>
<param><key>label</key><value>ch6_bb_in</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_6_0</value></param>
<param><key>label</key><value>ch6_bb_in</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_6_1</value></param>
<param><key>label</key><value>ch6_bb_in</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>quad_rate</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>sq_alpha</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>sq_ramp</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>squelch</value></param>
<param><key>value</key><value>0</value></param>
</block>
<connection><source_block_id>blocks_add_xx_0_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>nbfm_block_0_1_1_0</source_block_id><sink_block_id>blocks_add_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>nbfm_block_0_1_1_0_0</source_block_id><sink_block_id>blocks_add_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>nbfm_block_0_1_1_0_0_0</source_block_id><sink_block_id>blocks_add_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>nbfm_block_0_1_1_0_0_0_0</source_block_id><sink_block_id>blocks_add_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>nbfm_block_0_1_1_0_0_0_0_0</source_block_id><sink_block_id>blocks_add_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>4</sink_key></connection>
<connection><source_block_id>nbfm_block_0_1_1_0_0_0_0_0_0</source_block_id><sink_block_id>blocks_add_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>5</sink_key></connection>
<connection><source_block_id>nbfm_block_0_1_1_0_0_0_0_0_0_0</source_block_id><sink_block_id>blocks_add_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>6</sink_key></connection>
<connection><source_block_id>nbfm_block_0_1_1_0_0_0_0_0_0_0_0</source_block_id><sink_block_id>blocks_add_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>7</sink_key></connection>
<connection><source_block_id>nbfm_block_0_1_1_0_0_0_0_0_0_0_1</source_block_id><sink_block_id>blocks_add_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>8</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>nbfm_block_0_1_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_1</source_block_id><sink_block_id>nbfm_block_0_1_1_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_2</source_block_id><sink_block_id>nbfm_block_0_1_1_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_3</source_block_id><sink_block_id>nbfm_block_0_1_1_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_4</source_block_id><sink_block_id>nbfm_block_0_1_1_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_5</source_block_id><sink_block_id>nbfm_block_0_1_1_0_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_6</source_block_id><sink_block_id>nbfm_block_0_1_1_0_0_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_6_0</source_block_id><sink_block_id>nbfm_block_0_1_1_0_0_0_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_6_1</source_block_id><sink_block_id>nbfm_block_0_1_1_0_0_0_0_0_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
