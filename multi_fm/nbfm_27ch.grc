<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>nbfm_27ch</value></param>
<param><key>author</key><value>John Ackermann   N8UR   jra@febo.com</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>description</key><value>Derived from work by Chris Kuethe &lt;chris.kuethe+github@gmail.com&gt;</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>max_nouts</key><value>512</value></param>
<param><key>realtime_scheduling</key><value>1</value></param>
<param><key>title</key><value>27 Channel FM Receiver</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>audio_hw_rate</value></param>
<param><key>value</key><value>48000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>band_center</value></param>
<param><key>value</key><value>band_start + ((band_end - band_start)/2)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>band_end</value></param>
<param><key>value</key><value>band_start + ((num_chans +1) * ch_spacing)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>band_start</value></param>
<param><key>value</key><value>ch0_freq - ch_spacing</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>ch0_freq</value></param>
<param><key>value</key><value>ch0_init</value></param>
<param><key>gui_hint</key><value>0,0,1,2</value></param>
<param><key>label</key><value>Ch0 Freq</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>ch0_mute</value></param>
<param><key>value</key><value>1</value></param>
<param><key>gui_hint</key><value>1,0,1,1</value></param>
<param><key>label0</key><value>Mute</value></param>
<param><key>label1</key><value>Unmute</value></param>
<param><key>label</key><value>channel_names[0]</value></param>
<param><key>num_opts</key><value>2</value></param>
<param><key>option0</key><value>0</value></param>
<param><key>option1</key><value>1</value></param>
<param><key>type</key><value>int</value></param>
<param><key>widget</key><value>radio_buttons</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>ch10_mute</value></param>
<param><key>value</key><value>1</value></param>
<param><key>gui_hint</key><value>1,10,1,1</value></param>
<param><key>label0</key><value>Mute</value></param>
<param><key>label1</key><value>Unmute</value></param>
<param><key>label</key><value>channel_names[10]</value></param>
<param><key>num_opts</key><value>2</value></param>
<param><key>option0</key><value>0</value></param>
<param><key>option1</key><value>1</value></param>
<param><key>type</key><value>int</value></param>
<param><key>widget</key><value>radio_buttons</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>ch11_mute</value></param>
<param><key>value</key><value>1</value></param>
<param><key>gui_hint</key><value>2,0,1,1</value></param>
<param><key>label0</key><value>Mute</value></param>
<param><key>label1</key><value>Unmute</value></param>
<param><key>label</key><value>channel_names[11]</value></param>
<param><key>num_opts</key><value>2</value></param>
<param><key>option0</key><value>0</value></param>
<param><key>option1</key><value>1</value></param>
<param><key>type</key><value>int</value></param>
<param><key>widget</key><value>radio_buttons</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>ch12_mute</value></param>
<param><key>value</key><value>1</value></param>
<param><key>gui_hint</key><value>2,1,1,1</value></param>
<param><key>label0</key><value>Mute</value></param>
<param><key>label1</key><value>Unmute</value></param>
<param><key>label</key><value>channel_names[12]</value></param>
<param><key>num_opts</key><value>2</value></param>
<param><key>option0</key><value>0</value></param>
<param><key>option1</key><value>1</value></param>
<param><key>type</key><value>int</value></param>
<param><key>widget</key><value>radio_buttons</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>ch13_mute</value></param>
<param><key>value</key><value>1</value></param>
<param><key>gui_hint</key><value>2,2,1,1</value></param>
<param><key>label0</key><value>Mute</value></param>
<param><key>label1</key><value>Unmute</value></param>
<param><key>label</key><value>channel_names[13]</value></param>
<param><key>num_opts</key><value>2</value></param>
<param><key>option0</key><value>0</value></param>
<param><key>option1</key><value>1</value></param>
<param><key>type</key><value>int</value></param>
<param><key>widget</key><value>radio_buttons</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>ch14_mute</value></param>
<param><key>value</key><value>1</value></param>
<param><key>gui_hint</key><value>2,3,1,1</value></param>
<param><key>label0</key><value>Mute</value></param>
<param><key>label1</key><value>Unmute</value></param>
<param><key>label</key><value>channel_names[14]</value></param>
<param><key>num_opts</key><value>2</value></param>
<param><key>option0</key><value>0</value></param>
<param><key>option1</key><value>1</value></param>
<param><key>type</key><value>int</value></param>
<param><key>widget</key><value>radio_buttons</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>ch15_mute</value></param>
<param><key>value</key><value>1</value></param>
<param><key>gui_hint</key><value>2,4,1,1</value></param>
<param><key>label0</key><value>Mute</value></param>
<param><key>label1</key><value>Unmute</value></param>
<param><key>label</key><value>channel_names[15]</value></param>
<param><key>num_opts</key><value>2</value></param>
<param><key>option0</key><value>0</value></param>
<param><key>option1</key><value>1</value></param>
<param><key>type</key><value>int</value></param>
<param><key>widget</key><value>radio_buttons</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>ch16_mute</value></param>
<param><key>value</key><value>1</value></param>
<param><key>gui_hint</key><value>2,5,1,1</value></param>
<param><key>label0</key><value>Mute</value></param>
<param><key>label1</key><value>Unmute</value></param>
<param><key>label</key><value>channel_names[16]</value></param>
<param><key>num_opts</key><value>2</value></param>
<param><key>option0</key><value>0</value></param>
<param><key>option1</key><value>1</value></param>
<param><key>type</key><value>int</value></param>
<param><key>widget</key><value>radio_buttons</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>ch17_mute</value></param>
<param><key>value</key><value>1</value></param>
<param><key>gui_hint</key><value>2,6,1,1</value></param>
<param><key>label0</key><value>Mute</value></param>
<param><key>label1</key><value>Unmute</value></param>
<param><key>label</key><value>channel_names[17]</value></param>
<param><key>num_opts</key><value>2</value></param>
<param><key>option0</key><value>0</value></param>
<param><key>option1</key><value>1</value></param>
<param><key>type</key><value>int</value></param>
<param><key>widget</key><value>radio_buttons</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>ch18_mute</value></param>
<param><key>value</key><value>1</value></param>
<param><key>gui_hint</key><value>2,7,1,1</value></param>
<param><key>label0</key><value>Mute</value></param>
<param><key>label1</key><value>Unmute</value></param>
<param><key>label</key><value>channel_names[18]</value></param>
<param><key>num_opts</key><value>2</value></param>
<param><key>option0</key><value>0</value></param>
<param><key>option1</key><value>1</value></param>
<param><key>type</key><value>int</value></param>
<param><key>widget</key><value>radio_buttons</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>ch19_mute</value></param>
<param><key>value</key><value>1</value></param>
<param><key>gui_hint</key><value>2,8,1,1</value></param>
<param><key>label0</key><value>Mute</value></param>
<param><key>label1</key><value>Unmute</value></param>
<param><key>label</key><value>channel_names[19]</value></param>
<param><key>num_opts</key><value>2</value></param>
<param><key>option0</key><value>0</value></param>
<param><key>option1</key><value>1</value></param>
<param><key>type</key><value>int</value></param>
<param><key>widget</key><value>radio_buttons</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>ch1_mute</value></param>
<param><key>value</key><value>1</value></param>
<param><key>gui_hint</key><value>1,1,1,1</value></param>
<param><key>label0</key><value>Mute</value></param>
<param><key>label1</key><value>Unmute</value></param>
<param><key>label</key><value>channel_names[1]</value></param>
<param><key>num_opts</key><value>2</value></param>
<param><key>option0</key><value>0</value></param>
<param><key>option1</key><value>1</value></param>
<param><key>type</key><value>int</value></param>
<param><key>widget</key><value>radio_buttons</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>ch20_mute</value></param>
<param><key>value</key><value>1</value></param>
<param><key>gui_hint</key><value>2,9,1,1</value></param>
<param><key>label0</key><value>Mute</value></param>
<param><key>label1</key><value>Unmute</value></param>
<param><key>label</key><value>channel_names[20]</value></param>
<param><key>num_opts</key><value>2</value></param>
<param><key>option0</key><value>0</value></param>
<param><key>option1</key><value>1</value></param>
<param><key>type</key><value>int</value></param>
<param><key>widget</key><value>radio_buttons</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>ch21_mute</value></param>
<param><key>value</key><value>1</value></param>
<param><key>gui_hint</key><value>2,10,1,1</value></param>
<param><key>label0</key><value>Mute</value></param>
<param><key>label1</key><value>Unmute</value></param>
<param><key>label</key><value>channel_names[21]</value></param>
<param><key>num_opts</key><value>2</value></param>
<param><key>option0</key><value>0</value></param>
<param><key>option1</key><value>1</value></param>
<param><key>type</key><value>int</value></param>
<param><key>widget</key><value>radio_buttons</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>ch22_mute</value></param>
<param><key>value</key><value>1</value></param>
<param><key>gui_hint</key><value>3,0,1,1</value></param>
<param><key>label0</key><value>Mute</value></param>
<param><key>label1</key><value>Unmute</value></param>
<param><key>label</key><value>channel_names[22]</value></param>
<param><key>num_opts</key><value>2</value></param>
<param><key>option0</key><value>0</value></param>
<param><key>option1</key><value>1</value></param>
<param><key>type</key><value>int</value></param>
<param><key>widget</key><value>radio_buttons</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>ch23_mute</value></param>
<param><key>value</key><value>1</value></param>
<param><key>gui_hint</key><value>3,1,1,1</value></param>
<param><key>label0</key><value>Mute</value></param>
<param><key>label1</key><value>Unmute</value></param>
<param><key>label</key><value>channel_names[23]</value></param>
<param><key>num_opts</key><value>2</value></param>
<param><key>option0</key><value>0</value></param>
<param><key>option1</key><value>1</value></param>
<param><key>type</key><value>int</value></param>
<param><key>widget</key><value>radio_buttons</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>ch24_mute</value></param>
<param><key>value</key><value>1</value></param>
<param><key>gui_hint</key><value>3,2,1,1</value></param>
<param><key>label0</key><value>Mute</value></param>
<param><key>label1</key><value>Unmute</value></param>
<param><key>label</key><value>channel_names[24]</value></param>
<param><key>num_opts</key><value>2</value></param>
<param><key>option0</key><value>0</value></param>
<param><key>option1</key><value>1</value></param>
<param><key>type</key><value>int</value></param>
<param><key>widget</key><value>radio_buttons</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>ch25_mute</value></param>
<param><key>value</key><value>1</value></param>
<param><key>gui_hint</key><value>3,3,1,1</value></param>
<param><key>label0</key><value>Mute</value></param>
<param><key>label1</key><value>Unmute</value></param>
<param><key>label</key><value>channel_names[25]</value></param>
<param><key>num_opts</key><value>2</value></param>
<param><key>option0</key><value>0</value></param>
<param><key>option1</key><value>1</value></param>
<param><key>type</key><value>int</value></param>
<param><key>widget</key><value>radio_buttons</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>ch26_mute</value></param>
<param><key>value</key><value>1</value></param>
<param><key>gui_hint</key><value>3,4,1,1</value></param>
<param><key>label0</key><value>Mute</value></param>
<param><key>label1</key><value>Unmute</value></param>
<param><key>label</key><value>channel_names[26]</value></param>
<param><key>num_opts</key><value>2</value></param>
<param><key>option0</key><value>0</value></param>
<param><key>option1</key><value>1</value></param>
<param><key>type</key><value>int</value></param>
<param><key>widget</key><value>radio_buttons</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>ch2_mute</value></param>
<param><key>value</key><value>1</value></param>
<param><key>gui_hint</key><value>1,2,1,1</value></param>
<param><key>label0</key><value>Mute</value></param>
<param><key>label1</key><value>Unmute</value></param>
<param><key>label</key><value>channel_names[2]</value></param>
<param><key>num_opts</key><value>2</value></param>
<param><key>option0</key><value>0</value></param>
<param><key>option1</key><value>1</value></param>
<param><key>type</key><value>int</value></param>
<param><key>widget</key><value>radio_buttons</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>ch3_mute</value></param>
<param><key>value</key><value>1</value></param>
<param><key>gui_hint</key><value>1,3,1,1</value></param>
<param><key>label0</key><value>Mute</value></param>
<param><key>label1</key><value>Unmute</value></param>
<param><key>label</key><value>channel_names[3]</value></param>
<param><key>num_opts</key><value>2</value></param>
<param><key>option0</key><value>0</value></param>
<param><key>option1</key><value>1</value></param>
<param><key>type</key><value>int</value></param>
<param><key>widget</key><value>radio_buttons</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>ch4_mute</value></param>
<param><key>value</key><value>1</value></param>
<param><key>gui_hint</key><value>1,4,1,1</value></param>
<param><key>label0</key><value>Mute</value></param>
<param><key>label1</key><value>Unmute</value></param>
<param><key>label</key><value>channel_names[4]</value></param>
<param><key>num_opts</key><value>2</value></param>
<param><key>option0</key><value>0</value></param>
<param><key>option1</key><value>1</value></param>
<param><key>type</key><value>int</value></param>
<param><key>widget</key><value>radio_buttons</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>ch5_mute</value></param>
<param><key>value</key><value>1</value></param>
<param><key>gui_hint</key><value>1,5,1,1</value></param>
<param><key>label0</key><value>Mute</value></param>
<param><key>label1</key><value>Unmute</value></param>
<param><key>label</key><value>channel_names[5]</value></param>
<param><key>num_opts</key><value>2</value></param>
<param><key>option0</key><value>0</value></param>
<param><key>option1</key><value>1</value></param>
<param><key>type</key><value>int</value></param>
<param><key>widget</key><value>radio_buttons</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>ch6_mute</value></param>
<param><key>value</key><value>1</value></param>
<param><key>gui_hint</key><value>1,6,1,1</value></param>
<param><key>label0</key><value>Mute</value></param>
<param><key>label1</key><value>Unmute</value></param>
<param><key>label</key><value>channel_names[6]</value></param>
<param><key>num_opts</key><value>2</value></param>
<param><key>option0</key><value>0</value></param>
<param><key>option1</key><value>1</value></param>
<param><key>type</key><value>int</value></param>
<param><key>widget</key><value>radio_buttons</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>ch7_mute</value></param>
<param><key>value</key><value>1</value></param>
<param><key>gui_hint</key><value>1,7,1,1</value></param>
<param><key>label0</key><value>Mute</value></param>
<param><key>label1</key><value>Unmute</value></param>
<param><key>label</key><value>channel_names[7]</value></param>
<param><key>num_opts</key><value>2</value></param>
<param><key>option0</key><value>0</value></param>
<param><key>option1</key><value>1</value></param>
<param><key>type</key><value>int</value></param>
<param><key>widget</key><value>radio_buttons</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>ch8_mute</value></param>
<param><key>value</key><value>1</value></param>
<param><key>gui_hint</key><value>1,8,1,1</value></param>
<param><key>label0</key><value>Mute</value></param>
<param><key>label1</key><value>Unmute</value></param>
<param><key>label</key><value>channel_names[8]</value></param>
<param><key>num_opts</key><value>2</value></param>
<param><key>option0</key><value>0</value></param>
<param><key>option1</key><value>1</value></param>
<param><key>type</key><value>int</value></param>
<param><key>widget</key><value>radio_buttons</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>ch9_mute</value></param>
<param><key>value</key><value>1</value></param>
<param><key>gui_hint</key><value>1,9,1,1</value></param>
<param><key>label0</key><value>Mute</value></param>
<param><key>label1</key><value>Unmute</value></param>
<param><key>label</key><value>channel_names[9]</value></param>
<param><key>num_opts</key><value>2</value></param>
<param><key>option0</key><value>0</value></param>
<param><key>option1</key><value>1</value></param>
<param><key>type</key><value>int</value></param>
<param><key>widget</key><value>radio_buttons</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>ch_spacing</value></param>
<param><key>value</key><value>ch_spacing_init * 1000</value></param>
<param><key>gui_hint</key><value>0,2,1,1</value></param>
<param><key>label0</key><value>15 kHz</value></param>
<param><key>label1</key><value>20 kHz</value></param>
<param><key>label2</key><value>25 kHz</value></param>
<param><key>label3</key><value>30 kHz</value></param>
<param><key>label4</key><value>50 kHz</value></param>
<param><key>label</key><value>Spacing</value></param>
<param><key>num_opts</key><value>5</value></param>
<param><key>option0</key><value>15000</value></param>
<param><key>option1</key><value>20000</value></param>
<param><key>option2</key><value>25000</value></param>
<param><key>option3</key><value>30000</value></param>
<param><key>option4</key><value>50000</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>channel_map</value></param>
<param><key>value</key><value>range(0, num_chans)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>channel_names</value></param>
<param><key>value</key><value>map( lambda x: "%.3fMHz" % ( (ch0_freq+ (x*ch_spacing))/1e6) , channel_map)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>channelizer_map</value></param>
<param><key>value</key><value>14,15,16,17,18,19,20,21,22,23,24,25,26,0,1,2,3,4,5,6,7,8,9,10,11,12,13</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>decimation</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fm_dev</value></param>
<param><key>value</key><value>int(5e3)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>hardware_rate</value></param>
<param><key>value</key><value>sample_width * 2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>lpf_taps</value></param>
<param><key>value</key><value>firdes.low_pass(1.0, hardware_rate, sample_width/2,ch_spacing, firdes.WIN_HAMMING, 6.76)
</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>num_chans</value></param>
<param><key>value</key><value>27</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pfb_taps</value></param>
<param><key>value</key><value>firdes.low_pass(2.0, sample_width, ((fm_dev*2)+3e3),2500, firdes.WIN_HAMMING, 6.76)</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>ppm_corr</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>0,9,1,2</value></param>
<param><key>label</key><value>PPM Corr.</value></param>
<param><key>min_len</key><value>50</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-60</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>60</value></param>
<param><key>widget</key><value>slider</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>rf_gain</value></param>
<param><key>value</key><value>25</value></param>
<param><key>gui_hint</key><value>0,3,1,2</value></param>
<param><key>label</key><value>RF Gain</value></param>
<param><key>min_len</key><value>50</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>50</value></param>
<param><key>rangeType</key><value>int</value></param>
<param><key>widget</key><value>slider</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sample_width</value></param>
<param><key>value</key><value>ch_spacing * (num_chans + 1)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sq_alpha</value></param>
<param><key>value</key><value>0.0005</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sq_ramp</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>squelch</value></param>
<param><key>value</key><value>-40</value></param>
<param><key>gui_hint</key><value>0,7,1,2</value></param>
<param><key>label</key><value>Squelch</value></param>
<param><key>min_len</key><value>50</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-60</value></param>
<param><key>step</key><value>2</value></param>
<param><key>stop</key><value>-20</value></param>
<param><key>widget</key><value>slider</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tuner_freq</value></param>
<param><key>value</key><value>band_start - (0.1* hardware_rate)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tuner_offset</value></param>
<param><key>value</key><value>band_center - tuner_freq</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>volume</value></param>
<param><key>value</key><value>0.4</value></param>
<param><key>gui_hint</key><value>0,5,1,2</value></param>
<param><key>label</key><value>Volume</value></param>
<param><key>min_len</key><value>50</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>stop</key><value>1</value></param>
<param><key>widget</key><value>slider</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0</value></param>
<param><key>samp_rate</key><value>48000</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_inputs</key><value>3</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/jra/Band_Recordings/noaa_162.475_1M_16May2016_1048EDT.bin</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>volume</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samples_per_second</key><value>hardware_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>ch0_init</value></param>
<param><key>short_id</key><value>f</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>146.61e6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>ch_spacing_init</value></param>
<param><key>short_id</key><value>s</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>30</value></param>
</block>
<block>
<key>freq_xlating_fft_filter_ccc</key>
<param><key>id</key><value>freq_xlating_fft_filter_ccc_0</value></param>
<param><key>center_freq</key><value>tuner_offset  + ppm_corr</value></param>
<param><key>decim</key><value>decimation</value></param>
<param><key>samp_rate</key><value>hardware_rate</value></param>
<param><key>taps</key><value>lpf_taps</value></param>
</block>
<block>
<key>nbfm_block_9ch</key>
<param><key>id</key><value>nbfm_block_9ch_0</value></param>
<param><key>audio_rate</key><value>ch_spacing</value></param>
<param><key>fm_dev</key><value>fm_dev</value></param>
<param><key>mute0</key><value>ch0_mute</value></param>
<param><key>mute1</key><value>ch1_mute</value></param>
<param><key>mute2</key><value>ch2_mute</value></param>
<param><key>mute3</key><value>ch3_mute</value></param>
<param><key>mute4</key><value>ch4_mute</value></param>
<param><key>mute5</key><value>ch5_mute</value></param>
<param><key>mute6</key><value>ch6_mute</value></param>
<param><key>mute7</key><value>ch7_mute</value></param>
<param><key>mute8</key><value>ch8_mute</value></param>
<param><key>quad_rate</key><value>ch_spacing</value></param>
<param><key>sq_alpha</key><value>sq_alpha</value></param>
<param><key>sq_ramp</key><value>sq_ramp</value></param>
<param><key>squelch</key><value>squelch</value></param>
<bus_sink>1</bus_sink>
</block>
<block>
<key>nbfm_block_9ch</key>
<param><key>id</key><value>nbfm_block_9ch_1</value></param>
<param><key>audio_rate</key><value>ch_spacing</value></param>
<param><key>fm_dev</key><value>fm_dev</value></param>
<param><key>mute0</key><value>ch9_mute</value></param>
<param><key>mute1</key><value>ch10_mute</value></param>
<param><key>mute2</key><value>ch11_mute</value></param>
<param><key>mute3</key><value>ch12_mute</value></param>
<param><key>mute4</key><value>ch13_mute</value></param>
<param><key>mute5</key><value>ch14_mute</value></param>
<param><key>mute6</key><value>ch15_mute</value></param>
<param><key>mute7</key><value>ch16_mute</value></param>
<param><key>mute8</key><value>ch17_mute</value></param>
<param><key>quad_rate</key><value>ch_spacing</value></param>
<param><key>sq_alpha</key><value>sq_alpha</value></param>
<param><key>sq_ramp</key><value>sq_ramp</value></param>
<param><key>squelch</key><value>squelch</value></param>
<bus_sink>1</bus_sink>
</block>
<block>
<key>nbfm_block_9ch</key>
<param><key>id</key><value>nbfm_block_9ch_2</value></param>
<param><key>audio_rate</key><value>ch_spacing</value></param>
<param><key>fm_dev</key><value>fm_dev</value></param>
<param><key>mute0</key><value>ch18_mute</value></param>
<param><key>mute1</key><value>ch19_mute</value></param>
<param><key>mute2</key><value>ch20_mute</value></param>
<param><key>mute3</key><value>ch21_mute</value></param>
<param><key>mute4</key><value>ch22_mute</value></param>
<param><key>mute5</key><value>ch23_mute</value></param>
<param><key>mute6</key><value>ch24_mute</value></param>
<param><key>mute7</key><value>ch25_mute</value></param>
<param><key>mute8</key><value>ch26_mute</value></param>
<param><key>quad_rate</key><value>ch_spacing</value></param>
<param><key>sq_alpha</key><value>sq_alpha</value></param>
<param><key>sq_ramp</key><value>sq_ramp</value></param>
<param><key>squelch</key><value>squelch</value></param>
<bus_sink>1</bus_sink>
</block>
<block>
<key>osmosdr_source</key>
<param><key>id</key><value>osmosdr_source_0</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>freq0</key><value>tuner_freq</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>gain0</key><value>0</value></param>
<param><key>args</key><value>hackrf=0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>clock_source0</key><value>internal</value></param>
<param><key>time_source0</key><value>gpsdo</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>hardware_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>pfb_channelizer_ccf</key>
<param><key>id</key><value>pfb_channelizer_ccf</value></param>
<param><key>atten</key><value>1</value></param>
<param><key>bus_conns</key><value>[[0,1,2,3,4,5,6,7,8],[9,10,11,12,13,14,15,16,17],[18,19,20,21,22,23,24,25,26]]</value></param>
<param><key>ch_map</key><value>channelizer_map</value></param>
<param><key>nchans</key><value>num_chans</value></param>
<param><key>osr</key><value>1.0</value></param>
<param><key>taps</key><value>pfb_taps</value></param>
<bus_source>1</bus_source>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_1</value></param>
<param><key>average</key><value>0.1</value></param>
<param><key>bw</key><value>(fm_dev*2) + 3e3</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fftsize</key><value>512</value></param>
<param><key>gui_hint</key><value>3,0,1,5</value></param>
<param><key>label10</key><value></value></param>
<param><key>label2</key><value></value></param>
<param><key>label3</key><value></value></param>
<param><key>label4</key><value></value></param>
<param><key>label5</key><value></value></param>
<param><key>label6</key><value></value></param>
<param><key>label7</key><value></value></param>
<param><key>label8</key><value></value></param>
<param><key>label9</key><value></value></param>
<param><key>nconnections</key><value>num_chans</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.05</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>ymax</key><value>0</value></param>
<param><key>ymin</key><value>-100</value></param>
<bus_sink>1</bus_sink>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>entags</key><value>False</value></param>
<param><key>gui_hint</key><value>5,0,1,9</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value>Audio Out</value></param>
<param><key>name</key><value>Audio Output</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>audio_hw_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0_0_0</value></param>
<param><key>bw</key><value>num_chans * ch_spacing</value></param>
<param><key>fc</key><value>band_center</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>4,0,1,9</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>int_max</key><value>0</value></param>
<param><key>int_min</key><value>-100</value></param>
<param><key>color1</key><value>5</value></param>
<param><key>name</key><value>"Band Monitor"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.05</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0_0_0</value></param>
<param><key>decim</key><value>ch_spacing</value></param>
<param><key>interp</key><value>audio_hw_rate</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>rtlsdr_source</key>
<param><key>id</key><value>rtlsdr_source_0</value></param>
<param><key>bb_gain0</key><value>40</value></param>
<param><key>dc_offset_mode0</key><value>2</value></param>
<param><key>freq0</key><value>tuner_freq</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>30</value></param>
<param><key>gain0</key><value>rf_gain</value></param>
<param><key>args</key><value></value></param>
<param><key>clock_source0</key><value>internal</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>hardware_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
<param><key>center_freq0</key><value>tuner_freq</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>15</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>clock_source0</key><value>internal</value></param>
<param><key>sd_spec0</key><value>A:0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>hardware_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_1</value></param>
<param><key>stream_id</key><value>filtered_samples</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_2</value></param>
<param><key>stream_id</key><value>radio_samples</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0</value></param>
<param><key>stream_id</key><value>radio_samples</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_0</value></param>
<param><key>stream_id</key><value>filtered_samples</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_2_0</value></param>
<param><key>stream_id</key><value>filtered_samples</value></param>
</block>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>rational_resampler_xxx_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_throttle_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>audio_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fft_filter_ccc_0</source_block_id><sink_block_id>virtual_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>nbfm_block_9ch_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>nbfm_block_9ch_1</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>nbfm_block_9ch_2</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>virtual_sink_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ccf</source_block_id><sink_block_id>nbfm_block_9ch_0</sink_block_id><source_key>27</source_key><sink_key>9</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ccf</source_block_id><sink_block_id>nbfm_block_9ch_1</sink_block_id><source_key>28</source_key><sink_key>9</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ccf</source_block_id><sink_block_id>nbfm_block_9ch_2</sink_block_id><source_key>29</source_key><sink_key>9</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ccf</source_block_id><sink_block_id>nbfm_block_9ch_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ccf</source_block_id><sink_block_id>nbfm_block_9ch_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ccf</source_block_id><sink_block_id>nbfm_block_9ch_1</sink_block_id><source_key>10</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ccf</source_block_id><sink_block_id>nbfm_block_9ch_1</sink_block_id><source_key>11</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ccf</source_block_id><sink_block_id>nbfm_block_9ch_1</sink_block_id><source_key>12</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ccf</source_block_id><sink_block_id>nbfm_block_9ch_1</sink_block_id><source_key>13</source_key><sink_key>4</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ccf</source_block_id><sink_block_id>nbfm_block_9ch_1</sink_block_id><source_key>14</source_key><sink_key>5</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ccf</source_block_id><sink_block_id>nbfm_block_9ch_1</sink_block_id><source_key>15</source_key><sink_key>6</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ccf</source_block_id><sink_block_id>nbfm_block_9ch_1</sink_block_id><source_key>16</source_key><sink_key>7</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ccf</source_block_id><sink_block_id>nbfm_block_9ch_1</sink_block_id><source_key>17</source_key><sink_key>8</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ccf</source_block_id><sink_block_id>nbfm_block_9ch_2</sink_block_id><source_key>18</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ccf</source_block_id><sink_block_id>nbfm_block_9ch_2</sink_block_id><source_key>19</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ccf</source_block_id><sink_block_id>nbfm_block_9ch_0</sink_block_id><source_key>2</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ccf</source_block_id><sink_block_id>nbfm_block_9ch_2</sink_block_id><source_key>20</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ccf</source_block_id><sink_block_id>nbfm_block_9ch_2</sink_block_id><source_key>21</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ccf</source_block_id><sink_block_id>nbfm_block_9ch_2</sink_block_id><source_key>22</source_key><sink_key>4</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ccf</source_block_id><sink_block_id>nbfm_block_9ch_2</sink_block_id><source_key>23</source_key><sink_key>5</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ccf</source_block_id><sink_block_id>nbfm_block_9ch_2</sink_block_id><source_key>24</source_key><sink_key>6</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ccf</source_block_id><sink_block_id>nbfm_block_9ch_2</sink_block_id><source_key>25</source_key><sink_key>7</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ccf</source_block_id><sink_block_id>nbfm_block_9ch_2</sink_block_id><source_key>26</source_key><sink_key>8</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ccf</source_block_id><sink_block_id>nbfm_block_9ch_0</sink_block_id><source_key>3</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ccf</source_block_id><sink_block_id>nbfm_block_9ch_0</sink_block_id><source_key>4</source_key><sink_key>4</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ccf</source_block_id><sink_block_id>nbfm_block_9ch_0</sink_block_id><source_key>5</source_key><sink_key>5</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ccf</source_block_id><sink_block_id>nbfm_block_9ch_0</sink_block_id><source_key>6</source_key><sink_key>6</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ccf</source_block_id><sink_block_id>nbfm_block_9ch_0</sink_block_id><source_key>7</source_key><sink_key>7</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ccf</source_block_id><sink_block_id>nbfm_block_9ch_0</sink_block_id><source_key>8</source_key><sink_key>8</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ccf</source_block_id><sink_block_id>nbfm_block_9ch_1</sink_block_id><source_key>9</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0_0_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rtlsdr_source_0</source_block_id><sink_block_id>virtual_sink_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>virtual_sink_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0</source_block_id><sink_block_id>freq_xlating_fft_filter_ccc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_0</source_block_id><sink_block_id>pfb_channelizer_ccf</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_2_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
